SUMMARY = "A Python module to customize the process title"
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://COPYRIGHT;md5=86d2d41b5f4f023f43466f8cb7adebaa"

inherit pypi python_setuptools_build_meta

SRC_URI[sha256sum] = "ecf28b1c07a799d76f4326e508157b71aeda07b84b90368ea451c0710dbd32c0"
